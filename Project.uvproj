# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\Motor;.\HARDWARE\BLE;.\System\Time_PWM
  group Source Group 1
    ./: main.c
  group HARDWARE
    ./HARDWARE/Motor/: Motor.c
    ./HARDWARE/BLE/: ble.c
  group System
    ./System/Time_PWM/: PWM.c
